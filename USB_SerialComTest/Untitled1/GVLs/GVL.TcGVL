VAR_GLOBAL
	stComSerialCfg	: ComSerialConfig;
	fbUSBSerial		: SerialLineControlADS;
	RxBuffer		: ComBuffer;
	TxBuffer		: ComBuffer;
END_VAR
